File: placas/MOD/mod-AD&DA/mod-AD-DA-1.sch (KiCad schematic (older format))
At the start: 44 parts, among them P1 FPGA, U1 LP2951, U2 NJU7201, U3 MAX871, U4 LP2950, U5 AD5160, U6 ADC124S101, U7 DAC124S085, U8 TS924

Commit message: 
